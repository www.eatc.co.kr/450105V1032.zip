# Autodesk Inventor assembly: 조립도면
## iProperties
Created: 2015-01
Part Number: 조립도면
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
